<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AM35开关电源方案-24V-MSP430FR2155.ewp</path>
    </project>
    <batchBuild />
</workspace>
